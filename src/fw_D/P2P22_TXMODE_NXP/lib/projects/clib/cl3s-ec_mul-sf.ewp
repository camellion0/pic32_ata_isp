# IAR project cl3s-ec_mul-sf.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: 3 -v3, Max 64 Kbyte data, 128 Kbyte code
  ICCAVR.CCDefines: _SYSTEM_BUILD
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCOptLevel: 3
  group (top)
    ../../: cstartup.s90
  group Compiler support
    ../../: _exit.s90 debug.s90 eeprom.s90 l01.s90 l02.s90 l03.s90 l04.s90 l05.s90 l06.s90 l07.s90 l08.s90 l09.s90 l10.s90 l11.s90 l12.s90 low_level_init.c macros.m90 segment_init.c segment_init.h
  group Generic CLIB
    ../../clib/: abort.c abs.c acos.c asin.c assert.c atan.c atan2.c atof.c atoi.c atol.c bsearch.c calloc.c ceil.c cos.c cosh.c div.c errno.c exp.c exp10.c fabs.c floor.c fmod.c free.c frexp.c gets.c heap.c isalnum.c isalpha.c iscntrl.c isdigit.c isgraph.c islower.c isprint.c ispunct.c isspace.c isupper.c isxdigit.c labs.c ldexp.c ldiv.c log.c log10.c malloc.c memchr.c memcmp.c memcpy.c memmove.c memset.c modf.c pow.c printf.c puts.c qsort.c rand.c realloc.c satan.c scanf.c sin.c sinh.c sinus.c sprintf.c sqrt.c srand.c sscanf.c strcat.c strchr.c strcmp.c strcoll.c strcpy.c strcspn.c strerror.c strlen.c strncat.c strncmp.c strncpy.c strpbrk.c strrchr.c strspn.c strstr.c strtod.c strtok.c strtol.c strtoul.c strxfrm.c tan.c tanh.c tolower.c toupper.c vprintf.c vsprintf.c
  group Low level interface
    ../../dlib/: close.c lseek.c open.c read.c remove.c rename.c write.c
  group Specific AVR CLIB
    ../../clib/: _form_rd.c _form_wr.c _formatted_read_p.c _formatted_write_p.c _medi_rd.c _medi_wr.c _medium_read_p.c _medium_write_p.c _smal_wr.c _small_write_p.c ctype.s90 memcmp_G.c memcmp_P.c memcpy_G.c memcpy_p.c printf_p.c puts_G.c puts_p.c scanf_p.c sprintf_p.c sscanf_p.c strcat_G.c strcat_P.c strcmp_G.c strcmp_p.c strcpy_G.c strcpy_p.c strerror_p.c strlen_G.c strlen_p.c strncat_G.c strncat_P.c strncmp_G.c strncmp_p.c strncpy_G.c strncpy_p.c
