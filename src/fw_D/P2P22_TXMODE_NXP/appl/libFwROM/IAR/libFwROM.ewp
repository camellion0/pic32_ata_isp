# IAR project libFwROM.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: 3 -v3, Max 64 Kbyte data, 128 Kbyte code
  ICCAVR.newCCIncludePaths: C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.0\avr\inc
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: HAVE_BITREVERSAL
  XLINK.XclFile: ATA5700.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptStrategy: 0
  XLINK.XclFile: ATA5831.xcl
  group firmware/aes
    ../../../firmware/aes/src/: aes.c aes.h
  group firmware/calib
    ../../../firmware/calib/src/: calib.c calib.h
  group firmware/compiler
    ../../../firmware/compiler/src/: compiler.h
  group firmware/eep
    ../../../firmware/eep/src/: eep.c eep.h
  group firmware/globals
    ../../../firmware/globals/src/: globals.c globals.h globals_asm.s90 globals_defs.h globals_types.h
  group firmware/iic
    ../../../firmware/iic/src/: iic.c iic.h iic_asm.s90
  group firmware/init
    ../../../firmware/init/src/: init.c init.h
  group firmware/lfrssi
    ../../../firmware/lfrssi/src/: lfrssi.c lfrssi.h
  group firmware/lfrx
    ../../../firmware/lfrx/src/: lfrx.c lfrx.h
  group firmware/rfrcc
    ../../../firmware/rfrcc/src/: rfrcc.c rfrcc.h
  group firmware/rftx
    ../../../firmware/rftx/src/: rftx.c rftx.h rftx_ant.c rftx_ant.h rftx_defs.h rftx_vco.c rftx_vco.h
  group firmware/signatureTest
    ../../../firmware/signatureTest/src/: signatureTest_asm.s90
  group firmware/spi
    ../../../firmware/spi/src/: ata5831_command_set.c ata5831_command_set.h ata5831_command_set_asm.s90 spi.c spi.h spi_asm.s90
  group firmware/stdc
    ../../../firmware/stdc/src/: intrinsics.h ioATA5700.h iomacro.h regs.inc stdc.h
  group firmware/timer1
    ../../../firmware/timer1/src/: timer1.c timer1.h timer1_asm.s90
  group firmware/timer2
    ../../../firmware/timer2/src/: timer2.c timer2.h timer2_asm.s90
  group firmware/timer3
    ../../../firmware/timer3/src/: timer3.c timer3.h timer3_asm.s90
  group firmware/timer4
    ../../../firmware/timer4/src/: timer4.c timer4.h timer4_asm.s90
  group firmware/timer5
    ../../../firmware/timer5/src/: timer5.c timer5.h timer5_asm.s90
