<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\appFlash\IAR\appFLASH.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\lib\projects\clib\cl3s-ec_mul-sf.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libFwROM\IAR\libFwROM.ewp</path>
  </project>
  <batchBuild/>
</workspace>


