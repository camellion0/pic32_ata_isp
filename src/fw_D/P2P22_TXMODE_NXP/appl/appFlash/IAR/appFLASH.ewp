# IAR project appFLASH.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: 3 -v3, Max 64 Kbyte data, 128 Kbyte code
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: ATA5700_flash.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../src/: FlashAppl.c FlashApplAES.c FlashApplInOut.c FlashApplLF.c FlashApplPEPS.c FlashApplRF.c FlashApplRKE.c FlashApplSPI.c FlashIrq.c inttable_flash_asm.s90 rfrcc_flash.c utils.c
  group firmware
    ../../../firmware/rftx/src/: rftx_flash.c rftx_flash.h
  group firmware/compiler
    ../../../firmware/compiler/src/: compiler.h
  group firmware/eep
    ../../../firmware/eep/src/: eep.h eep_flash.c eep_flash.h
  group firmware/extif
    ../../../firmware/extif/src/: extif_asm_flash.s90 extif_flash.c extif_flash.h
  group firmware/globals
    ../../../firmware/globals/src/: globals.h globals_defs.h globals_flash.c globals_flash.h globals_types.h
  group firmware/init
    ../../../firmware/init/src/: init_flash.c init_flash.h
  group firmware/lfrssi
    ../../../firmware/lfrssi/src/: lfrssi_flash.c lfrssi_flash.h
  group firmware/lfrx
    ../../../firmware/lfrx/src/: lfrx_flash.c lfrx_flash.h lfrx_immo.h lfrx_immo_flash.c
  group firmware/spi
    ../../../firmware/spi/src/: ata5700_command_set_asm_flash.s90 ata5700_command_set_flash.c spi_flash.c
  group firmware/stdc
    ../../../firmware/stdc/src/: intrinsics.h regs.inc stdc.h
  group firmware/system
    ../../../firmware/system/src/: system_asm_flash.s90 system_flash.c system_flash.h
  group firmware/timer1
    ../../../firmware/timer1/src/: timer1_asm_flash.s90
  group firmware/timer2
    ../../../firmware/timer2/src/: timer2_asm_flash.s90
  group firmware/timer3
    ../../../firmware/timer3/src/: timer3_asm_flash.s90 timer3_flash.c timer3_flash.h
  group firmware/timer4
    ../../../firmware/timer4/src/: timer4_asm_flash.s90 timer4_flash.c timer4_flash.h
  group firmware/timer5
    ../../../firmware/timer5/src/: timer5_asm_flash.s90
  group firmware/tp
    ../../../firmware/tp/src/: tp_asm_flash.s90 tp_flash.c tp_flash.h
